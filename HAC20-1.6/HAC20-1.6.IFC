Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView]
File name: D:\Skimmer Lids\Lids and Recess Frames\Confirmed Cutting tracks\HAC 506 x 40\HAC 506 x 40 kit.IFC
Time: 2025-04-11T05:14:31+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC2X3

# IfcProject, Project
Description: Default Project
